# Keil uVision project iValuableUnit.uvprojx, settings and files
target Debug (ARM-ADS)
  device: LPC11C24FBD48/301 NXP
  pack: Keil.LPC1100_DFP.1.3.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: iValuableUnit
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Source
    ./: main.cpp SensorArray.cpp System.cpp ScaleInfo.cpp
  group Driver
    ./: display.cpp fram.cpp hx711.cpp delay.c
  group Peripheral
    ./: uart.c ssp.c gpio.c canonchip.c timer32.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5, Device:Startup 1.0.0
